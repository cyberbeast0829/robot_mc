# Keil uVision project mit_h473.uvprojx, settings and files
target mit_h473 (6180000::V6.18::ARMCLANG)
  device: N32H473CE Nationstech
  pack: Nationstech.N32H47x_DFP.1.0.0
  cpu: IRAM(0x20000000,0x30000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: mit_h473 +hex
  c flags: Optim=5 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=8 wLevel=1
  c define: N32H473,ARM_MATH_CM4,HSE_VALUE=24000000,__weak="__attribute__((weak))",__packed="__attribute__((__packed__))"
  c include: ..\Core\Inc;..\Drivers\CMSIS\core;..\Drivers\CMSIS\device;..\Drivers\n32h47x_48x_std_periph_driver\inc
  asm define: __MICROLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x30000
  scatter file: .\ODrive_N32.sct
  group Core
    ../Core/Src/: adc.c calibration.c can.c flash_writer.c foc.c fsm.c gpio.c main.c math_ops.c n32h47x_48x_it.c position_sensor.c preference_writer.c spi.c syscalls.c sysmem.c system_n32h47x_48x.c tim.c usart.c
  group N32_Driver
    ../Drivers/n32h47x_48x_std_periph_driver/src/: misc.c n32h47x_48x_adc.c n32h47x_48x_comp.c n32h47x_48x_cordic.c n32h47x_48x_crc.c n32h47x_48x_dac.c n32h47x_48x_dbg.c n32h47x_48x_dma.c n32h47x_48x_dvp.c n32h47x_48x_eth.c n32h47x_48x_exti.c n32h47x_48x_fdcan.c n32h47x_48x_femc.c n32h47x_48x_flash.c n32h47x_48x_fmac.c n32h47x_48x_gpio.c n32h47x_48x_i2c.c n32h47x_48x_iwdg.c n32h47x_48x_lptim.c n32h47x_48x_pga.c n32h47x_48x_pwr.c n32h47x_48x_rcc.c n32h47x_48x_rtc.c n32h47x_48x_sdio.c n32h47x_48x_shrtim.c n32h47x_48x_spi.c n32h47x_48x_tim.c n32h47x_48x_usart.c n32h47x_48x_vrefbuf.c n32h47x_48x_wwdg.c n32h47x_48x_xspi.c
  group CMSIS
    ../Drivers/CMSIS/core/: arm_common_tables.c
    ../Drivers/CMSIS/device/startup/: startup_n32h473.s
software components: CMSIS:CORE 6.1.0
